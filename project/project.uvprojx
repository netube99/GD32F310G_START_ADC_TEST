# Keil uVision project project.uvprojx, settings and files
target GD32F310G8 (6160000::V6.16::ARMCLANG)
  device: GD32F310G8 GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.0.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32F310,USE_STDPERIPH_DRIVER
  c include: ..\code\bsp\include;..\code\device\CMSIS\Include;..\code\device\GD32F3x0_standard_peripheral\Include;..\code\user\include;..\code\rtos\components\finsh;..\code\rtos\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USER
    ../code/user/source/: gd32f3x0_it.c main.c systick.c
  group BSP
    ../code/bsp/source/: bsp_adc.c bsp_uart.c
  group DEVICE
    ../code/device/CMSIS/Source/: startup_gd32f3x0.s system_gd32f3x0.c
    ../code/device/GD32F3x0_standard_peripheral/Source/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
  group RTTHREAD
    ../code/rtos/components/device/: device.c
    ../code/rtos/components/finsh/: cmd.c finsh_port.c msh.c shell.c
    ../code/rtos/source/: board.c clock.c components.c context_rvds.S cpu.c cpuport.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
